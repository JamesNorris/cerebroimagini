# Keil uVision project ci_stm32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ci_stm32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F411VETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F411VETx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 5.1.1, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:CRC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:Flash 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:HCD 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:I2S 1.7.4, Device:STM32Cube HAL:IRDA 1.7.4, Device:STM32Cube HAL:IWDG 1.7.4, Device:STM32Cube HAL:MMC 1.7.4, Device:STM32Cube HAL:PCD 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:RTC 1.7.4, Device:STM32Cube HAL:SD 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:Smartcard 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:STM32Cube HAL:USART 1.7.4, Device:STM32Cube HAL:WWDG 1.7.4, Device:Startup 2.6.2
